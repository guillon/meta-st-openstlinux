EXTRA_OECONF_remove_class-native = "--with-tclinclude=${STAGING_INCDIR}/tcl8.6"

BBCLASSEXTEND = "native nativesdk"

