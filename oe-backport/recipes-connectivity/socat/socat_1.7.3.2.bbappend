PACKAGECONFIG_remove_class-native = "tcp-wrappers"

BBCLASSEXTEND = "native nativesdk"
