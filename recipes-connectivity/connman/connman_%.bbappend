# Disable connman service at startup
SYSTEMD_AUTO_ENABLE_${PN} = "disable"
