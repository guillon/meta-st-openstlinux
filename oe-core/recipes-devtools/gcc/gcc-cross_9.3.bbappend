FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://1001-TEMPORARY-GCC-PLUGIN-install-all-headers.patch"
