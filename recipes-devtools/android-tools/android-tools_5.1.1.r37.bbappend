SRCREV_FORMAT = "core"
