#
# Due to GPLv3 limitation, gdbserver are removed of package group
#
RDEPENDS_${PN}_remove = "\
    gdbserver \
    "
