RDEPENDS_${PN}_remove = "\
    ${LTTNGMODULES} \
    "

#RDEPENDS_append += "oprofile"
