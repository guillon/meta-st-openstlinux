SRCREV = "658ae538f76a2624b7f9c40539a600d281d872b4"

PV = "2.2.0"
PR = "git${SRCPV}.r0"

include optee-client.inc
