SRCREV = "17d1addc465a667f375837cdbe4fa7ebac08539b"

PV = "2.1.0"
PR = "git${SRCPV}.r0"

LIC_FILES_CHKSUM = "file://LICENSE;md5=69663ab153298557a59c67a60a743e5b"

include optee-client.inc
