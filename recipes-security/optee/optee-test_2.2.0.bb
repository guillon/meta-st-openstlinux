include optee-test.inc

SRCREV = "a00eeb15ddfaa5b7d2cb340faeb36748d5aabffb"

PV = "2.2.0"
PR = "git${SRCPV}.r0"
