include optee-client.inc

SRCREV = "88acd6bda5f9e19124fce0015fe64a6644eff036"

PV = "2.0.0"
PR = "git${SRCPV}.r0"
