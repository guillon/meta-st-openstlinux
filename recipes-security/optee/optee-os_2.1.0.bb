include optee-os.inc

SRCREV = "ac3cc1102a081a7fe2b0446d38c6a484c2e9b26f"

PV = "2.1.0"
PR = "git${SRCPV}.r0"
